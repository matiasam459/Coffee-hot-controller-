# Keil uVision project Proyecto.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: STM32F334R8Tx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.2
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Proyecto
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Group 1
    ./: main.c proyecto.h PWM_setup.c ADC_setup.c I2C_setup.c PID_setup.c UART_setup.c
software components: CMSIS:CORE 5.6.0, Device:STM32Cube HAL:ADC 1.11.3, Device:STM32Cube HAL:CAN 1.11.3, Device:STM32Cube HAL:CEC 1.11.3, Device:STM32Cube HAL:COMMON 1.11.3, Device:STM32Cube HAL:COMP 1.11.3, Device:STM32Cube HAL:CORTEX 1.11.3, Device:STM32Cube HAL:CRC 1.11.3, Device:STM32Cube HAL:DAC 1.11.3, Device:STM32Cube HAL:DMA 1.11.3, Device:STM32Cube HAL:EXTI 1.11.3, Device:STM32Cube HAL:FLASH 1.11.3, Device:STM32Cube HAL:GPIO 1.11.3, Device:STM32Cube HAL:HRTIM 1.11.3, Device:STM32Cube HAL:I2C 1.11.3, Device:STM32Cube HAL:I2S 1.11.3, Device:STM32Cube HAL:IRDA 1.11.3, Device:STM32Cube HAL:IWDG 1.11.3, Device:STM32Cube HAL:OPAMP 1.11.3, Device:STM32Cube HAL:PWR 1.11.3, Device:STM32Cube HAL:RCC 1.11.3, Device:STM32Cube HAL:RTC 1.11.3, Device:STM32Cube HAL:SDADC 1.11.3, Device:STM32Cube HAL:SMARTCARD 1.11.3, Device:STM32Cube HAL:SMBUS 1.11.3, Device:STM32Cube HAL:SPI 1.11.3, Device:STM32Cube HAL:TIM 1.11.3, Device:STM32Cube HAL:TSC 1.11.3, Device:STM32Cube HAL:UART 1.11.3, Device:STM32Cube HAL:USART 1.11.3, Device:STM32Cube HAL:WWDG 1.11.3, Device:Startup 1.11.3
